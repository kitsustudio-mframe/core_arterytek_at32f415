# Keil uVision project core.uvprojx, settings and files
target chip (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: core (library)
  AfterMake: cmd.exe /C copy .keil\Objects\core.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415RBT7
  c include: .\..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: CoreChip.cpp CoreChip.h CoreHardwareInfo.cpp CoreHardwareInfo.h CoreInterrupt.cpp CoreInterrupt.h CoreIomux.cpp CoreIomux.h CoreTimer.cpp CoreTimer.h CoreUSART.cpp CoreUSART.h package-info.h
  group src/digital
    ./digital/: CoreEdgeTrigger.cpp CoreEdgeTrigger.h CoreGeneralPin.cpp CoreGeneralPin.h CoreGeneralPort.cpp CoreGeneralPort.h InputMode.h OutputMode.h package-info.h
  group resource
    ./resource/: chip_interrupt.cpp chip_startup.s
